# Keil uVision project peripherals.uvprojx, settings and files
target LandTiger (test) (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: peripherals-test-baremetal
  c flags: Optim=5 v6Lang=5 v6LangP=3 wLevel=2
  c include: .\Source\Libs\Button;.\Source\CMSIS_core;.\Source;.\Source\Libs\RIT;.\Source\Libs\Timer;.\Source\Libs\LED;.\Source\Libs\Power;.\Source\Libs\Utils;.\Source\Tests;.\Source\Libs\SysTick;.\Source\Libs\Joystick;.\Source\Libs\ADC-PM;.\Source\Libs\DAC;.\Source\Libs\GLCD;.\Source\Libs\GLCD\Fonts;.\Source\Libs\TouchPanel;.\Source\System;.\Source\Libs
  asm include: .\Source\button_EXINT;.\Source\CMSIS_core;.\Source\led;.\Source\RIT;.\Source
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group CMSIS
    ./Source/CMSIS_core/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm3.h mpu_armv7.h
  group RIT
    ./Source/Libs/RIT/: rit.c rit.h rit_job.c rit_types.h
  group LED
    ./Source/Libs/LED/: led.c led.h led_types.h
  group Timer
    ./Source/Libs/Timer/: timer.c timer.h timer_types.h timer_irq.c
  group Power
    ./Source/Libs/Power/: power.c power.h power_types.h
  group Utils
    ./Source/Libs/Utils/: utils.h
  group Joystick
    ./Source/Libs/Joystick/: joystick.c joystick.h joystick_types.h
  group System
    ./Source/System/: startup_LPC17xx.s system_LPC17xx.c system.h
  group ADC-PM
    ./Source/Libs/ADC-PM/: adc_pm.c adc_pm.h adc_pm_irq.c adc_pm_types.h
  group DAC
    ./Source/Libs/DAC/: dac.c dac.h dac_dma.c dac_types.h
  group GLCD
    ./Source/Libs/GLCD/: glcd.c glcd.h glcd_types.h
  group Buttons
    ./Source/Libs/Button/: button.c button.h button_irq.c button_types.h
  group TouchPanel
    ./Source/Libs/TouchPanel/: touch.c touch.h
  group Tests
    ./Source/Tests/: test.c
  group Systick
    ./Source/Libs/SysTick/: delay.c delay.h delay.s
target Simulator (test) (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: as above
  output: peripherals-test-sim
  c flags: Optim=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: SIMULATOR
  c misc: -MMD -MF ./Objects/%I.d -MJ ./Objects/%I.json
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Library (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: as above
  output: peripherals (library)
  c flags: Optim=4 v6Lang=5 v6LangP=3 wLevel=2
  c define: SIMULATOR
  c misc: -MMD -MF compile-commands.d -MJ compile-commands.json
  c include: .\Source\Libs\Button;.\Source\CMSIS_core;.\Source;.\Source\Libs\RIT;.\Source\Libs\Timer;.\Source\Libs\LED;.\Source\Libs\Power;.\Source\Libs\Utils;.\Source\Libs\SysTick;.\Source\Libs\Joystick;.\Source\Libs\ADC-PM;.\Source\Libs\DAC;.\Source\Libs\GLCD;.\Source\Libs\GLCD\Fonts;.\Source\Libs\TouchPanel;.\Source\Libs
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 6.1.0, Device:GPDMA 1.4.0
