# Keil uVision project lib.uvprojx, settings and files
target LandTiger (test) (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sample-board
  c flags: Optim=5 v6Lang=5 v6LangP=3 wLevel=2
  c include: .\Source\CMSIS_core;.\Source\System;.\Source\Program;.\Libs\BigLib\Include
  asm include: .\Source\button_EXINT;.\Source\CMSIS_core;.\Source\led;.\Source\RIT;.\Source
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: .\Libs\BigLib\big-lib.lib
  group CMSIS
    ./Source/CMSIS_core/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm3.h mpu_armv7.h
  group System
    ./Source/System/: startup_LPC17xx.s system_LPC17xx.c
  group Program
    ./Source/Program/: main.c
target Simulator (test) (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: as above
  output: sample-emulator
  c flags: Optim=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: SIMULATOR
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: .\Libs\BigLib\big-lib.lib
software components: CMSIS:CORE 6.1.0, Device:GPDMA 1.4.0, Device:PIN 1.0.0
